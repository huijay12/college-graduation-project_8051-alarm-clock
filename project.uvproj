# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: MPC82E52A Megawin
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(45000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c DS1307.c eeprom.c I2C.c LCD.c delay.c servo.c
